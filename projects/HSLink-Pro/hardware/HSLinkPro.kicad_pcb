# Repository cherry-embedded/CherryDAP

File README.md:

# CherryDAP

CherryDAP is a DAPLink template based on [CherryUSB](https://github.com/sakumisu/CherryUSB) and [ARMmbed DAPLink](https://github.com/ARMmbed/DAPLink).

# Feature

- CMSIS DAP version 2.1, only support winusb
- Support SWD + JTAG + CJTAG
- Support USB2UART
- Support webusb
- Support custom hid

# Projects

- [bl616](projects/bl616/README.md)
- [esp32s3](projects/esp32s3/README.md)
- [HSLink-Lite](projects/HSLink-Lite/README.md)
- [HSLink-Pro](projects/HSLink-Pro/README.md)

## KiCad design projects/HSLink-Pro/hardware/HSLinkPro.kicad_pcb

File projects/HSLink-Pro/hardware/README.md:

# HSLinkPro

## 本仓库不再更新！！

新的参考设计: <https://github.com/cherry-embedded/CherryDAP/tree/master/projects/HSLink-Pro/hardware>

HSLink Pro是一款基于HPM5301系列MCU的调试器。最高SWD/JTAG通信速率可达80M，并且拥有一路USB转串口，并带有DTR与RTS的输出，方便某些串口下载的MCU应用。

HSLink Pro软件参考<https://github.com/cherry-embedded/CherryDAP>。

## KiCAD 版本

使用8.0以上版本的KiCAD打开。

Parts:
C21, C22: 15p; C_0402_1005Metric
C23, C57: 0.1u; C_0402_1005Metric
D1: WS2812B; LED_WS2812_0807
D2: 1N5819; D_SOD-523
J3: Header 1.27 4P; PinHeader_1x04_P1.27mm_Vertical; not fitted
R1, R17, R18: 10k; R_0402_1005Metric
R2, R9, R10, R11, R12, R21: 100k; R_0402_1005Metric
R22, R23: 22R; R_0402_1005Metric
SW1: 1TS028A-1900-0600-CT; SW-SMD_4P-L2.8-W1.9-P1.20-LS3.0_1TS028A
U1: HPM5301IEG1; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm
Y1: 24M; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: J3.1, R1.1, SW1.2; also elsewhere on the board
+5V: D2.2 (A); also elsewhere on the board
/ADC_TVCC: R11.2, R12.1, U1.26 (PB09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI2.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)
/ADC_VREF: R9.2, R10.1, U1.27 (PB08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI2.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)
/BOOT0: R17.1, U1.8 (PA02/TMR1.COMP1/URT0.DE/URT0.RTS/I2C0.S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)
/BOOT1: R18.1, SW1.1, U1.7 (PA03/TMR1.CAPT1/URT0.CTS/I2C0.SDA/SPI3.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)
/ISP_RX: J3.3, U1.11 (PA01/TMR1.CAPT0/URT0.RXD/TRGM0.P01/ACMP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)
/ISP_TX: J3.2, U1.12 (PA00/TMR1.COMP0/URT0.TXD/TRGM0.P00)
/NRST: C23.1, R1.2, U1.13 (~RESETN)
/PORT_EN: R2.1, U1.1 (PA04/URT1.CTS/SPI0.CS0/TRGM0.P04/JTAG.T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); also elsewhere on the board
/P_EN: R21.1, U1.37 (PA31/SPI1.DAT3/XPI0.CA_CS0/TRGM0.P07/US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); also elsewhere on the board
/SPI_CS: U1.25 (PB10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI2.C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), U1.42 (PA26/SPI1.CS0/XPI0.CA_D3/TRGM0.P02)
/SRST: U1.20 (PB15/TMR0.COMP3/URT3.TXD/SPI2.DAT3/TRGM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); also elsewhere on the board
/SWCLK/TCK: U1.24 (PB11/URT2.CTS/SPI2.SCLK/ACMP.COMP1/ADC0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), U1.41 (PA27/SPI1.SCLK/XPI0.CA_SCLK/TRGM0.P03); also elsewhere on the board
/SWDIO_DIR: U1.38 (PA30/SPI1.DAT2/XPI0.CA_D1/TRGM0.P06/USB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); also elsewhere on the board
/SWDIO/TMS: R22.1, R23.1; also elsewhere on the board
/TDI: U1.22 (PB13/TMR1.COMP3/URT3.DE/URT3.RTS/I2C3.S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); also elsewhere on the board
/TDO: U1.23 (PB12/URT3.CTS/I2C3.SDA/SPI2.MISO/TRGM0.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); also elsewhere on the board
/TRANS_PWM: U1.4 (PA10/TMR0.COMP2/URT2.DE/URT2.RTS/SPI3.C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); also elsewhere on the board
/TRST: U1.21 (PB14/URT3.RXD/SPI2.DAT2/TRGM0.P02/ADC0.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); also elsewhere on the board
/UART_DTR: U1.47 (PA06/TMR0.CAPT0/URT1.RXD/I2C1.SDA/SPI0.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); also elsewhere on the board
/UART_RTS: U1.48 (PA05/TMR1.COMP2/URT1.DE/URT1.RTS/SPI0.S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); also elsewhere on the board
/UART_RX: U1.3 (PA09/TMR0.CAPT1/URT2.RXD/I2C2.SDA/SPI3.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); also elsewhere on the board
/UART_TX: U1.2 (PA08/TMR0.COMP1/URT2.TXD/I2C2.SCL/SPI3.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); also elsewhere on the board
/USB_D+: U1.44 (PA24/I2C2.SCL/SPI1.CS2/XPI0.CA_CS1/TRGM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); also elsewhere on the board
/USB_D-: U1.43 (PA25/I2C2.SDA/SPI1.CS1/XPI0.CA_DQS/TRGM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); also elsewhere on the board
/VREF: R9.1; also elsewhere on the board
/WS2812: D1.4 (DIN), U1.46 (PA07/TMR0.COMP0/URT1.TXD/I2C1.SCL/SPI0.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)
/XIN: C21.1, U1.35 (XTALI), Y1.1
/XOUT: C22.1, U1.36 (XTALO), Y1.3
GND: C21.2, C22.2, C23.2, C57.2, D1.3 (VSS), J3.4, R2.2, R10.2, R12.2, R17.2, R18.2, R21.2, Y1.2, Y1.4; also elsewhere on the board
unnamed: C57.1, D1.1 (VDD), D2.1 (K)
unnamed: R22.2, U1.40 (PA28/I2C3.SDA/SPI1.MISO/XPI0.CA_D0/TRGM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)
unnamed: R23.2, U1.39 (PA29/I2C3.SCL/SPI1.MOSI/XPI0.CA_D2/TRGM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)
TRANS_VCC: R11.1; also elsewhere on the board

Parts:
C55, C56: 10u; C_0603_1608Metric
C58: 100u; CP_EIA-3528-21_Kemet-B
J1: IDC 2x10p 夹板; Conn_02x10_IDC_SMD
J2: USB_C_Receptacle_USB2.0; USB-C-SMD_CX90M-16P
R14, R15: 5.1k; R_0402_1005Metric
R16: 4.7k; R_0402_1005Metric
U14: MT9700; SOT-23-5
U15, U16, U17, U18: ESD0524P; DFN-10_L2.5-W1.0-P0.50-BL-A

Connections:
+5V: C55.2, C58.1, U14.1 (VOUT); also elsewhere on the board
+5V_OUT: J1.19; also elsewhere on the board
/Interface /<NO NET>: J1.5, U16.2, U16.9; also elsewhere on the board
/Interface /SRST: J1.15, U17.2, U17.9; also elsewhere on the board
/Interface /SWCLK/TCK: J1.9, U16.5, U16.6; also elsewhere on the board
/Interface /SWDIO/TMS: J1.7, U16.4, U16.7; also elsewhere on the board
/Interface /TDO: J1.13, U17.1, U17.10; also elsewhere on the board
/Interface /TRST: J1.3, U16.1, U16.10; also elsewhere on the board
/Interface /UART_DTR: J1.14, U18.1, U18.10; also elsewhere on the board
/Interface /UART_RTS: J1.16, U18.2, U18.9; also elsewhere on the board
/Interface /UART_RX: J1.20, U18.5, U18.6; also elsewhere on the board
/Interface /UART_TX: J1.18, U18.4, U18.7; also elsewhere on the board
/USB_D+: J2.A6 (D+), J2.B6 (D+), U15.5, U15.6; also elsewhere on the board
/USB_D-: J2.A7 (D-), J2.B7 (D-), U15.4, U15.7; also elsewhere on the board
/VREF: J1.1; also elsewhere on the board
GND: C55.1, C56.2, C58.2, J1.4, J1.6, J1.8, J1.10, J1.12, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R14.2, R15.2, R16.1, U14.2 (GND), U15.1, U15.2, U15.3, U15.8, U15.9, U15.10, U16.3, U16.8, U17.3, U17.4, U17.5, U17.6, U17.7, U17.8, U18.3, U18.8; also elsewhere on the board
unnamed: J2.A5 (CC1), R14.1
unnamed: J2.B5 (CC2), R15.1
unnamed: R16.2, U14.3 (SET)
TRANS_VCC_OUT: J1.2; also elsewhere on the board
VBUS: C56.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), U14.4 (EN), U14.5 (VIN)

Parts:
C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C36, C37, C38, C39, C42, C43, C44, C45: 0.1u; C_0402_1005Metric
Q1: 2N7002; SOT-323_SC-70
R3: 100k; R_0402_1005Metric
R13: 1k; R_0402_1005Metric
R24, R25, R26, R27: 22R; R_0402_1005Metric
R28, R30, R31, R32, R33: 100R; R_0402_1005Metric
U2, U3, U4, U5, U6, U8, U9, U11, U12: SN74LVC1T45DCK; SOT-363_SC-70-6

Connections:
+3V3: C24.2, C26.2, C28.2, C30.2, C32.2, C36.2, C38.2, C42.2, C44.2, U2.1 (VCCA), U2.5 (DIR), U3.1 (VCCA), U4.1 (VCCA), U5.1 (VCCA), U5.5 (DIR), U6.1 (VCCA), U6.5 (DIR), U8.1 (VCCA), U8.5 (DIR), U9.1 (VCCA), U11.1 (VCCA), U11.5 (DIR), U12.1 (VCCA), U12.5 (DIR); also elsewhere on the board
/Interface /<NO NET>: R27.2; also elsewhere on the board
/Interface /SRST: Q1.3 (D), R13.2; also elsewhere on the board
/Interface /SWCLK/TCK: R24.2; also elsewhere on the board
/Interface /SWDIO/TMS: R25.2; also elsewhere on the board
/Interface /TDO: R26.2; also elsewhere on the board
/Interface /TRST: R28.2; also elsewhere on the board
/Interface /UART_DTR: R32.2; also elsewhere on the board
/Interface /UART_RTS: R33.2; also elsewhere on the board
/Interface /UART_RX: R31.2; also elsewhere on the board
/Interface /UART_TX: R30.2; also elsewhere on the board
/SRST: Q1.1 (G), R3.1; also elsewhere on the board
/SWCLK/TCK: U2.3 (A); also elsewhere on the board
/SWDIO_DIR: U3.5 (DIR); also elsewhere on the board
/SWDIO/TMS: U3.3 (A); also elsewhere on the board
/TDI: U5.3 (A); also elsewhere on the board
/TDO: U4.3 (A); also elsewhere on the board
/TRST: U6.3 (A); also elsewhere on the board
/UART_DTR: U11.3 (A); also elsewhere on the board
/UART_RTS: U12.3 (A); also elsewhere on the board
/UART_RX: U9.3 (A); also elsewhere on the board
/UART_TX: U8.3 (A); also elsewhere on the board
GND: C24.1, C25.2, C26.1, C27.2, C28.1, C29.2, C30.1, C31.2, C32.1, C33.2, C36.1, C37.2, C38.1, C39.2, C42.1, C43.2, C44.1, C45.2, Q1.2 (S), R3.2, U2.2 (GND), U3.2 (GND), U4.2 (GND), U4.5 (DIR), U5.2 (GND), U6.2 (GND), U8.2 (GND), U9.2 (GND), U9.5 (DIR), U11.2 (GND), U12.2 (GND); also elsewhere on the board
unnamed: R24.1, U2.4 (B)
unnamed: R25.1, U3.4 (B)
unnamed: R26.1, U4.4 (B)
unnamed: R27.1, U5.4 (B)
unnamed: R28.1, U6.4 (B)
unnamed: R30.1, U8.4 (B)
unnamed: R31.1, U9.4 (B)
unnamed: R32.1, U11.4 (B)
unnamed: R33.1, U12.4 (B)
TRANS_VCC: R13.1; also elsewhere on the board
VEE: C25.1, C27.1, C29.1, C31.1, C33.1, C37.1, C39.1, C43.1, C45.1, U2.6 (VCCB), U3.6 (VCCB), U4.6 (VCCB), U5.6 (VCCB), U6.6 (VCCB), U8.6 (VCCB), U9.6 (VCCB), U11.6 (VCCB), U12.6 (VCCB); also elsewhere on the board

Parts:
C1, C3, C5, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C34, C47, C53: 0.1u; C_0402_1005Metric
C2, C6, C40: 4.7u; C_0402_1005Metric
C4, C9: 10u; C_0402_1005Metric
C7, C8: 22u; C_0402_1005Metric
C41, C46: 22u; C_0603_1608Metric
C48, C49, C51, C59, C60, C61, C62, C63: 1u; C_0402_1005Metric
C50: 6.8p; C_0402_1005Metric
C52, C54: 1n; C_0402_1005Metric
L1: 4.7uH; L_Murata_DFE201610P
L2: 2.2uH; L_Murata_DFE201610P
R4, R5: 100k; R_0402_1005Metric
R6: 15.8k; R_0402_1005Metric
R7: 88.7k; R_0402_1005Metric
R8: 150k; R_0402_1005Metric
U1: HPM5301IEG1; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm
U7, U21, U22: TPS22965; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm
U10: TLV62568DRL; SOT-563
U13: LMV321; SOT-353_SC-70-5
U19: ME6211C33R5; SOT-353_SC-70-5

Connections:
+3V3: C4.1, C5.1, C11.1, C12.1, C13.1, C14.1, C15.1, C49.1, U1.6 (VIO_B00), U1.16 (VPMC), U1.29 (VIO_B01), U1.31 (VREFH), U1.32 (VANA), U1.34 (VIO_B00), U19.5 (V_{OUT}); also elsewhere on the board
+5V: C34.1, C40.1, C48.1, C51.1, C53.1, U10.3 (VIN), U10.5 (EN), U13.5 (V+), U19.1 (V_{IN}), U19.3 (CE), U22.1 (V_{IN}), U22.2 (V_{IN}), U22.4 (VBIAS); also elsewhere on the board
+5V_OUT: C59.1, U22.7 (V_{OUT}), U22.8 (V_{OUT}); also elsewhere on the board
/PORT_EN: U7.3 (ON); also elsewhere on the board
/P_EN: U21.3 (ON), U22.3 (ON); also elsewhere on the board
/Power/TRANS_FB: C50.2, R4.2, R5.1, R6.1, U10.1 (FB)
/Power/TRANS_VREF: C52.2, R5.2, U13.3 (-), U13.4
/TRANS_PWM: R7.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C34.2, C40.2, C41.2, C46.2, C47.2, C48.2, C49.2, C51.2, C53.2, C54.2, C59.2, C60.2, C61.2, C62.2, C63.2, R6.2, U1.30 (VREFL), U1.49 (VSS), U7.5 (GND), U7.9 (EP), U10.2 (GND), U13.2 (V-), U19.2 (V_{SS}), U21.5 (GND), U21.9 (EP), U22.5 (GND), U22.9 (EP); also elsewhere on the board
unnamed: C52.1, R7.2, R8.1
unnamed: L1.2, U1.15 (DCDC_LP)
unnamed: C3.1, C6.1, U1.10 (VDD_OTPCAP)
unnamed: C1.1, C2.1, U1.17 (VDD_PMCCAP)
unnamed: L2.1, U10.4 (SW)
unnamed: C54.1, R8.2, U13.1 (+)
TRANS_VCC: C41.1, C46.1, C47.1, C50.1, C60.1, C62.1, L2.2, R4.1, U7.1 (V_{IN}), U7.2 (V_{IN}), U7.4 (VBIAS), U21.1 (V_{IN}), U21.2 (V_{IN}), U21.4 (VBIAS); also elsewhere on the board
TRANS_VCC_OUT: C61.1, U21.7 (V_{OUT}), U21.8 (V_{OUT}); also elsewhere on the board
VDD_SOC: C7.1, C8.1, C9.1, C10.1, C16.1, C17.1, C18.1, C19.1, C20.1, L1.1, U1.5 (VDD_SOC), U1.9 (VDD_SOC), U1.28 (VDD_SOC), U1.33 (VDD_SOC), U1.45 (VDD_SOC)
VEE: C63.1, U7.7 (V_{OUT}), U7.8 (V_{OUT}); also elsewhere on the board

Notes on the sheet:
TRANS_VREF的电压范围为0-3.3V 映射到TRANS_VCC上的电压为1.7-5V

Board: 4 copper layers, 26.0 x 35.0 mm, 123 parts (0 on the bottom side), 70 nets.

## Code that names these connections

File projects/HSLink-Pro/src/DAP_config.h (part):

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    HPM_IOC->PAD[PIN_TDO].PAD_CTL = IOC_PAD_PAD_CTL_PRS_SET(2);
    HPM_IOC->PAD[PIN_TDO].FUNC_CTL = IOC_PAD_FUNC_CTL_ALT_SELECT_SET(0);

    HPM_IOC->PAD[PIN_SRST].PAD_CTL = IOC_PAD_PAD_CTL_PRS_SET(2);
    HPM_IOC->PAD[PIN_SRST].FUNC_CTL = IOC_PAD_FUNC_CTL_ALT_SELECT_SET(0);

    HPM_IOC->PAD[PIN_JTAG_TRST].PAD_CTL = IOC_PAD_PAD_CTL_PRS_SET(2);
    HPM_IOC->PAD[PIN_JTAG_TRST].FUNC_CTL = IOC_PAD_FUNC_CTL_ALT_SELECT_SET(0);
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    gpio_disable_pin_interrupt(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_TDO), GPIO_GET_PIN_INDEX(PIN_TDO));
    gpiom_set_pin_controller(HPM_GPIOM, GPIO_GET_PORT_INDEX(PIN_TDO), GPIO_GET_PIN_INDEX(PIN_TDO), PIN_GPIOM);

    gpio_set_pin_input(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_SRST), GPIO_GET_PIN_INDEX(PIN_SRST));
    gpio_disable_pin_interrupt(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_SRST), GPIO_GET_PIN_INDEX(PIN_SRST));
    gpiom_set_pin_controller(HPM_GPIOM, GPIO_GET_PORT_INDEX(PIN_SRST), GPIO_GET_PIN_INDEX(PIN_SRST), PIN_GPIOM);

    gpio_set_pin_input(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_JTAG_TRST), GPIO_GET_PIN_INDEX(PIN_JTAG_TRST));
    gpio_disable_pin_interrupt(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_JTAG_TRST), GPIO_GET_PIN_INDEX(PIN_JTAG_TRST));
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*/
__STATIC_FORCEINLINE uint32_t PIN_SWDIO_TMS_IN(void)
{
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(SWDIO_DIR), GPIO_GET_PIN_INDEX(SWDIO_DIR), 0);
    uint32_t sta = gpio_read_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_TMS), GPIO_GET_PIN_INDEX(PIN_TMS));
    __asm volatile("fence io, io");
    return sta;
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*/
__STATIC_FORCEINLINE void PIN_SWDIO_TMS_SET(void)
{
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(SWDIO_DIR), GPIO_GET_PIN_INDEX(SWDIO_DIR), 1);
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_TMS), GPIO_GET_PIN_INDEX(PIN_TMS), true);
    __asm volatile("fence io, io");
}
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*/
__STATIC_FORCEINLINE void PIN_SWDIO_TMS_CLR(void)
{
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(SWDIO_DIR), GPIO_GET_PIN_INDEX(SWDIO_DIR), 1);
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_TMS), GPIO_GET_PIN_INDEX(PIN_TMS), false);
    __asm volatile("fence io, io");
}
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*/
__STATIC_FORCEINLINE uint32_t PIN_SWDIO_IN(void)
{
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(SWDIO_DIR), GPIO_GET_PIN_INDEX(SWDIO_DIR), 0);
    uint32_t sta = gpio_read_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_TMS), GPIO_GET_PIN_INDEX(PIN_TMS));
    __asm volatile("fence io, io");
    return sta;
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*/
__STATIC_FORCEINLINE void PIN_SWDIO_OUT(uint32_t bit)
{
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(SWDIO_DIR), GPIO_GET_PIN_INDEX(SWDIO_DIR), 1);
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_TMS), GPIO_GET_PIN_INDEX(PIN_TMS), bit & 0x01);
    __asm volatile("fence io, io");
}
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*/
__STATIC_FORCEINLINE void PIN_SWDIO_OUT_ENABLE(void)
{
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(SWDIO_DIR), GPIO_GET_PIN_INDEX(SWDIO_DIR), 1);
    HPM_IOC->PAD[PIN_TMS].FUNC_CTL = IOC_PAD_FUNC_CTL_ALT_SELECT_SET(0); /* as gpio*/
    HPM_IOC->PAD[PIN_TMS].PAD_CTL = IOC_PAD_PAD_CTL_PRS_SET(2) | IOC_PAD_PAD_CTL_PE_SET(1) | IOC_PAD_PAD_CTL_PS_SET(1);
    gpio_set_pin_output(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_TMS), GPIO_GET_PIN_INDEX(PIN_TMS));
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*/
__STATIC_FORCEINLINE void PIN_SWDIO_OUT_DISABLE(void)
{
    gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(SWDIO_DIR), GPIO_GET_PIN_INDEX(SWDIO_DIR), 0);
    HPM_IOC->PAD[PIN_TMS].PAD_CTL = IOC_PAD_PAD_CTL_PRS_SET(2);
    HPM_IOC->PAD[PIN_TMS].FUNC_CTL = IOC_PAD_FUNC_CTL_ALT_SELECT_SET(0);
    gpio_set_pin_input(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_TMS), GPIO_GET_PIN_INDEX(PIN_TMS));
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}

/** nTRST I/O pin: Set Output.
\param bit JTAG TRST Test Reset pin status:
           - 0: issue a JTAG TRST Test Reset.
           - 1: release JTAG TRST Test Reset.
*/
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*/
__STATIC_FORCEINLINE uint32_t PIN_nRESET_IN(void)
{
    uint32_t sta = gpio_read_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_SRST), GPIO_GET_PIN_INDEX(PIN_SRST));
    __asm volatile("fence io, io");
    return sta;
}
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{
    if (bit & 0x01) {
        if (SETTING_GET_RESET_MODE(HSLink_Setting.reset, RESET_NRST)) {
            gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_SRST), GPIO_GET_PIN_INDEX(PIN_SRST), !HSLink_Global.reset_level);
        }
    } else {
        if (SETTING_GET_RESET_MODE(HSLink_Setting.reset, RESET_NRST)) {
            gpio_write_pin(PIN_GPIO, GPIO_GET_PORT_INDEX(PIN_SRST), GPIO_GET_PIN_INDEX(PIN_SRST), HSLink_Global.reset_level);
        }
        if (SETTING_GET_RESET_MODE(HSLink_Setting.reset, RESET_ARM_SWD_SOFT)) {
            software_reset();
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
## Commit log (part)

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2023-12-02 project: hpm5301evklite: Fixed the problem of serial port and debugging working at the same time due to turning on optimization
2024-04-20 Fixed the problem of swd download problem
2024-04-21 projects: hpm5301evklite: adapt hpm_sdk version to v1.5.0
    - fixed uart issue
    - update cmakelists file
2024-07-14 The details are as follows:
    - Distinguish between onboard 20P and custom pin
    - Support IO over JTAG
    - Support changing LED RST and other pins in cmakelists file
    - support Adjust frequency for swj clock
2024-07-26 add: 添加外部接口功能
2024-08-08 add: 添加uf2conv
2024-08-08 add: bootloader工程
2024-08-08 fix: CONFIG_BOOTUF2_FLASHMAX错误
2024-08-08 fix: uf2 config
2024-08-09 chore: 添加HPM_WS2812库
2024-08-11 add: 添加BL区和APP区的一些配置
2024-08-11 chore: 构建完成自动生成uf2
2024-08-11 chore: 添加APP_NAME
2024-08-11 fix: SWDIO_DIR相关初始化
2024-08-11 feat: 添加长按BL按键回到BOOT功能
2024-08-11 feat: 添加版本号
2024-08-11 projects: hpm5301evklite: add jtag over single jtag
2024-08-11 GitHub Action support (#1)
    add Github Action support
2024-08-12 fix: 版本号获取接口换成统一的
2024-08-12 chore: 添加自动更新版本号的功能
2024-08-13 add: 添加HID设备描述符
2024-08-14 add: 添加自动确定接口描述符的位置
2024-08-15 add: 添加App工程
2024-08-15 add: 添加Github Action
2024-08-15 feat: 在bootloader里面加入对于外设的初始化
2024-08-15 update: 更新路径
2024-08-15 chore: 可通过外部宏指定FW_VER
2024-08-15 feat: 添加用于配置的HID接口
2024-08-26 fix: 关闭HID接口的时候有些代码会编译出错
2024-08-30 chore: CI添加上传APP区域的bin文件
2024-08-30 release: 2.2.1
2024-08-31 chore: 更新CherryUSB库到1.4.0
2024-08-31 chore: 统一脚本路径
2024-08-31 fix: 文件一起上传
2024-08-31 fix: 脚本路径错误
2024-08-31 fix: some warning
2024-08-31 fix: HID部分接口更新到CherryUSB 1.4.0
2024-08-31 fix: 让退出bl的时候灯珠始终保持关闭
2024-08-31 chore: 将XPI0的长度修改为128k，方便检查
2024-08-31 add: app中添加WS2812驱动
2024-08-31 format: 格式化代码
2024-08-31 fix: SWDIO空闲的时候默认为输入状态，由target拉高
2024-08-31 release: 2.2.2
2024-09-01 fix: 增加对TMS的电平转换方向控制
2024-09-01 fix: JTAG下DIR有误
2024-09-02 fix: 先使用GPIO模拟JTAG
2024-09-04 add: 添加README
2024-09-04 fix: 修改P_EN的IO端口
2024-09-04 fix: 加入了IO模拟SWD的DIR切换
2024-09-04 fix: UART引脚切换
2024-09-04 fix: IO模拟SWD时序
2024-09-04 release: 2.2.4.IO
2024-09-05 Add HSLink Pro board (#11)
    * The details are as follows:
    - Distinguish between onboard 20P and custom pin
    - Support IO over JTAG
    - Support changing LED RST and other pins in cmakelists file
    - support Adjust frequency for swj clock
    * projects: hpm5301evklite: add jtag over single jtag
2024-09-05 update(bl616): update bl616 board
2024-09-06 fix: 不需要板载LED初始化
2024-09-06 fix: P_EN引脚初始化有误
2024-09-07 chore: 将SWDIO_DIR设置放在CMakeLists.txt种进行
2024-09-07 fix: 解决一些Warning
2024-09-07 perf: SPI模拟SWD频率计算优化
2024-09-07 feat: SWD模式自动切换SPI模式和IO模式，兼容更宽频率
2024-09-07 Fixed some issues with HSLink Pro boards (#13)
    * fix: 使用GPIO0来控制SWDIO_DIR，减少玄学问题
    * fix: 不需要板载LED初始化
    * fix: P_EN引脚初始化有误
    * add: 添加硬件设计
    * chore: 将SWDIO_DIR设置放在CMakeLists.txt种进行
    * fix: 解决一些Warning
2024-09-08 fix: 修复SPI模拟JTAG时序问题
2024-09-08 fix: JTAG下的IR数据有误
2024-09-08 feat: 增加JTAG下自动切换SPI和IO模式
2024-09-08 HSLink Pro adds automatic switching between IO and SPI analogue modes to increase compatibility (#14)
    * fix: 修复SPI模拟JTAG时序问题
    * fix: JTAG下的IR数据有误
    * feat: 增加JTAG下自动切换SPI和IO模式
    * fix: 解决IO和SPI互相切换的过程中导致的错误
2024-09-09 fix: HSLink Pro board not initialising TRST/SRST pins (#15)
2024-09-10 [HSLink-Pro] fix delay issues for uart rx to usb
2024-09-11 [HSLink-Pro] fix data error that may be caused by interrupt preemption processing
2024-09-11 [HSLink-Pro] modify to correct number of descriptors and remove excess dma tx buffer
2024-09-15 projects: hpm5301evklite: fixed some issue
2024-09-15 projects: hslink-pro: fixed the problem of low-rate programming error
    - the ack response should keep the lower three bits valid for swd
    - trn should be variable length, 1 to 4 clock cycles for SPI_SWD_Transfer API
    - idle_cycles should be valid for read and write operations for SPI_SWD_Transfer API
2024-09-21 Bugfix/swd sometimes work fail (#17)
    * projects: hpm5301evklite: fixed some issue
    * projects: hslink-pro: fixed the problem of low-rate programming error
    - the ack response should keep the lower three bits valid for swd
    - trn should be variable length, 1 to 4 clock cycles for SPI_SWD_Transfer API
    - idle_cycles should be valid for read and write operations for SPI_SWD_Transfer API
    * projects: hslink-pro: improve CLK clock output accuracy
2024-09-22 fix: 修复FGPIO相关错误
2024-09-22 fix: 修复FGPIO相关错误 (#18)
2024-09-22 fix: 修复了SWD和JTAG相互切换无法识别的情况
2024-09-22 chore: 添加其它IDE文件的生成
2024-09-22 feat: 文档站
2024-09-22 feat: 添加CDC的输出RTS和DTR功能
2024-09-22 feat: 添加CDC的输出RTS和DTR功能 (#21)
2024-09-23 feat: 实现CMSIS-DAP的一些接口 (#19)
2024-09-23 fix: 主题色错误
2024-09-23 docs: 添加HSLink Pro的描述
2024-09-23 Initial gh-pages commit
2024-09-23 Deploying to gh-pages from @ cherry-embedded/CherryDAP@c6ea238076440799632f69be55486388f79a9051 🚀
2024-09-27 Deploying to gh-pages from @ cherry-embedded/CherryDAP@82507f60e18bb6160f5a5c29780f701bf5c06f6f 🚀
2024-09-27 Deploying to gh-pages from @ cherry-embedded/CherryDAP@c658db77d5f980c5c6580a75caea9d52fa167d09 🚀
2024-09-27 refactor: 优化工程结构
2024-09-27 fix: 路径大小写错误
2024-09-27 refactor: 优化工程结构 (#26)
2024-09-28 fix: 修复hid相关构建错误
2024-12-28 update: 更新电源部分
2024-12-28 update: 更新原理图
2024-12-30 update: 添加RTT LOGO
2025-01-02 fix: sdk 8.0
2025-01-02 feat: 加入端口控制
2025-01-02 fix: 更换hpm sdk
2025-01-02 fix: 更新编译器路径
2025-01-02 fix: bl工程也更新sdk
2025-01-02 chore: CherryUSB更新到1.4.2
2025-01-02 Deploying to gh-pages from @ cherry-embedded/CherryDAP@cce42508ea3e3d8b9b2c1c6742ae4f09fadec2a9 🚀
2025-01-02 fix: 添加CI写入权限
2025-01-07 chore: 添加cJSON库
2025-01-08 feat: 添加与上位机的HID通信接口
2025-01-08 fix: 修复描述符错误
2025-01-09 feat: 添加上位机下发设置功能
2025-01-09 fix: 修复可能的一些错误
2025-01-11 fix: 修复写入flash死机问题
2025-01-11 chore: 添加tlsf
2025-01-11 chore: 切换cJSON库位置
2025-01-11 feat: 添加首次默认设置
2025-01-11 feat: 添加硬件版本号
2025-01-12 feat: 添加获取设置
2025-01-12 feat: 重构为cpp
2025-01-13 fix: 修复release下可能会崩溃的玄学问题
2025-01-15 fix: 修复RapidJSON库所需内存
2025-01-15 fix: 修复nickname设置问题
2025-01-15 fix: BL工程里面关闭所有输出
2025-01-15 fix: 修复一些warning
2025-01-15 fix: get_setting字段错误
2025-01-17 update: 1.2.0硬件
2025-01-17 feat: 添加upgrade命令
2025-01-17 fix: 将硬件版本号放在OTP寄存器中
2025-03-05 fix: PWM输出极性反了
2025-03-05 fix: 1.2.0硬件修改IO
2025-03-05 HSLink-Pro: 2.3.1 (#29)
    * update: 更新电源部分
    * update: 更新原理图
    * update: 更新PCB
    - 修改定位孔位置
    - 修改Type-C位置
    * update: 添加RTT LOGO
2025-03-08 remove submodule
2025-03-08 move submodule
2025-03-09 move board to common as a custom board fix some clock may not be enabled
2025-03-09 init wdg for old bl that may not init wdg
2025-03-09 fix mem
2025-03-09 better replaceSubstring
2025-03-09 chore: 更新文档版本
2025-03-09 Deploying to gh-pages from @ cherry-embedded/CherryDAP@7159665ab3871c7d44813d134248c82fb0ca5e40 🚀
2025-03-15 fix: SRST的电平修改
2025-03-15 fix: 更换识别硬件的OTP地址
2025-03-15 Deploying to gh-pages from @ cherry-embedded/CherryDAP@0815c0f9ce6f32f35dfffc0e083c0c658b7a3ba8 🚀
2025-03-15 enable ws2812 when bl, using gpio polling
2025-03-15 * add multibutton to replace button in bl, add led blink when bl waiting button, for better button keep bl experience * fix ws2812 rgb order * fix ws2812 may blink when power on, may be caused by cac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
2025-03-15 add led in dap
2025-03-15 Deploying to gh-pages from @ cherry-embedded/CherryDAP@61aded730cc3cfccaf847ba12479abe90241d114 🚀
2025-03-15 enhance: add hw_ver in flash and api to modify it
2025-03-15 enhance: enable ws2812 on hslink pro, using gpio polling (#31)
    * enable ws2812 when bl, using gpio polling
    * * add multibutton to replace button in bl, add led blink when bl waiting button, for better button keep bl experience
    * fix ws2812 rgb order
    * fix ws2812 may blink when power on, may be caused by cache miss, move then to itcm
    * * move ws2812 to bsp
    * replace button using multibutton to support more button action
2025-03-17 bl: use ld in hpm_sdk 1.8.0
2025-03-19 enhance: hw1.2: ws2812 using spi
2025-03-19 fix: neopixel bit order
2025-03-20 hslink: Enable ws2812 on hw v1.2.x (#32)
2025-03-22 enhance: add version upload
2025-03-22 enhance: add version upload (#33)
2025-03-23 feat: 添加LED动效
2025-03-23 release: 2.3.4
2025-03-23 perf: 在进入BL之前关闭LED
2025-03-23 fix: 上位机设置的LED是否开启无效
2025-03-24 enhance: add elog fix: boot would fail when led is off
2025-03-24 enhance: add elog (#36)
    fix: boot would fail when led is off
2025-03-24 Commit submodule changes - by UGit
2025-03-24 move log
2025-03-24 refactor: replace hpm eeprom with fal+flashdb (support fal)
2025-03-25 refactor: replace hpm eeprom with fal+flashdb (refactor settings api)
2025-03-25 fix: ws2812 io polling time may not quiet current in different compile options, so force to -O2
2025-03-25 refactor: hpm eeprom emulation -> fal+flashdb (#37)
2025-03-27 remove: a pin level get from version func, we should enhance getter in a better way in the future
2025-03-27 submodule
2025-03-27 clean up
2025-03-27 enhance: add error reply to upper
2025-03-27 hslink: Support upgrade bootloader (#38)
2025-03-28 docs: 更新文档
2025-03-28 Deploying to gh-pages from @ cherry-embedded/CherryDAP@4be22be4d461dbe3fc8545403edf06e331016a21 🚀
2025-03-29 doc: update hslink doc (#39)
2025-03-29 Deploying to gh-pages from @ cherry-embedded/CherryDAP@dd49d7ebc3dcbcf813f5ddd964e86640cd4c930a 🚀
2025-03-29 release: 2.4.0
2025-03-29 Deploying to gh-pages from @ cherry-embedded/CherryDAP@e516d54f0a50b717936fa0849a994e3a1efd7494 🚀
2025-03-29 hslink: fix: some error in part cfg (#40)
    * fix: some error in part cfg
    * fix: ld
2025-03-29 Deploying to gh-pages from @ cherry-embedded/CherryDAP@faa26f4a0f287c266890d8412f86afb03ce04bf4 🚀
2025-03-29 fix: download reset mode do not clear
2025-04-03 CherryDAP on ESP32s3
2025-04-03 CherryDAP on ESP32s3 (#43)
2025-04-03 hslink: update doc
2025-04-03 hslink: update doc (#44)
2025-04-04 esp32s3 remove redundant usbd config code in chry_dap_init()
2025-04-06 hslink: add how to fix uart messy
2025-04-06 Deploying to gh-pages from @ cherry-embedded/CherryDAP@7c678c24a16ae19cc5dc3db7d77813c41756840b 🚀
2025-04-06 fix: settings read from flash
2025-04-07 fix: gpio模拟的jtag存在问题
2025-04-07 fix: hpm sdk 固定1.8.0
2025-04-07 feat: 可切换的JTAG单bit GPIO模拟
2025-04-07 docs: 增加上位机配置文档
2025-04-07 Deploying to gh-pages from @ cherry-embedded/CherryDAP@fd72478d55046dacf1487ad7768e1024e5786c67 🚀
2025-04-07 release: 2.4.1
2025-04-07 Deploying to gh-pages from @ cherry-embedded/CherryDAP@72fb2156184370db64c201a24d5ec81e5f7fbab2 🚀
2025-04-08 perf: 使用FGPIO作为控制器 (#49)
2025-04-08 chore: 修改docs ci触发条件
2025-04-08 feat: 添加JTAG 20P兼容模式
2025-04-08 feat: 添加JTAG 20P兼容模式 (#50)
2025-04-09 support ws2812 on v1.3.0
2025-04-09 rebase to master
2025-04-09 easy to read
2025-04-09 hslink: support hw 1.3.0 (#52)
    * support hslink hw 1.3.0
2025-04-20 fix: nickname (#55)
2025-04-20 fix: SRST level
2025-04-24 add comm failed faq
2025-04-24 Deploying to gh-pages from @ cherry-embedded/CherryDAP@4b24f04f216022bd997aa50d9606d1af05a16fce 🚀
2025-04-26 support hpm sdk 1.9.0 (#57)
2025-05-15 doc: add ProductionGuide link
2025-05-15 Deploying to gh-pages from @ cherry-embedded/CherryDAP@e94c021d560ef8faed6e5573ef1a5345a9e8c96b 🚀
2025-06-02 change b64 lib to mainline
2025-06-10 fix: SWD_Sequence stuck in spi mode when req bits less than 8
2025-06-27 fix(hslink-pro): remove ununsed macros
2025-06-27 feat(hslink-ob): add hslink ob project
2025-06-30 Revert "fix(hslink-pro): remove ununsed macros"
    This reverts commit e470cc1c7177a6d399d85edc3ef6dd653683b940.
2025-06-30 refactor: implement Set_Clock_Delay with io & spi, no use macro
2025-06-30 update: enable serial number dynamic
2025-06-30 refactor: merge hid config into dap_main
2025-06-30 feat: enable webusb
2025-06-30 docs: update 5301evklite readme
2025-07-01 update: change web url
2025-07-01 update: remove stm32f4 project
2025-07-23 doc: add faq about short connect vref&tvcc
2025-07-23 Deploying to gh-pages from @ cherry-embedded/CherryDAP@3ea472c997e23e69352439795c33ab38da7326f2 🚀
2025-08-05 enhance: add async for reset
2025-08-05 fix: por reset change to modify setting temporarily
2025-08-06 hslink: add button trigger reset (#67)
2025-11-20 style: format pin code
2025-11-20 fix: make reset level standard, reset level means active level in reset
2025-11-26 fix: remove jtag shift mode
2025-11-26 release: 2.4.3
2025-12-09 Reverse reset level on hw 1.3.x
2025-12-09 Reverse reset level on hw 1.3.x (#73)
2025-12-13 hslink: add HSLink-Iso max speed limit
2025-12-13 hslink: add HSLink-Iso CI build script
2025-12-13 hslink: add HSLink-Iso version port
2026-04-22 Revert "hslink: gpio mode swd timing optimize"
    This reverts commit d97fec7d18e63f830168191f742b784540c0ac14.
2026-05-06 feat: add hslinklite
2026-05-07 update(hslinklite): enable vee for hslink pro
2026-05-07 update(hslinklite): set tms and tck with loopback, no need reconfig gpio input mode
2026-05-07 update(hslinklite): adapter for hpm5301evklite
2026-05-07 update(hslinklite): only set tms to 0 when call TMS_IN
2026-05-08 update(hslinklite): enable power for hslink pro

Notices in the files:
projects/HSLink-Pro/src/DAP_config.h:
Copyright (c) 2013-2021 ARM Limited. All rights reserved.
SPDX-License-Identifier: Apache-2.0
Licensed under the Apache License, Version 2.0 (the License); you may
